# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: Project +hex
  c flags: Optimize=9
  c misc: interval(3)
  c include: ..\..\Libraries\Include;..\..\User;..\..\User\lib;..\..\Hardware
  asm include: ..\..\Libraries;..\..\Libraries\C51
  group Startup
    ../../Libraries/Startup/: STARTUP.A51
    ../../Libraries/Source/: system.c
  group LIb
    ../../User/lib/: tk_set.c tk_simplify_algorithm_V1.0.0.LIB
  group Hardware
    ../../Hardware/: tmr1.c tmr2.c uart0.c adc.c key_driver.c user_flash.c aip3368.c
  group User
    ../../User/: main.c user_config.h pin_level_scan.c speed_scan.c engine_speed_scan.c mileage.c fuel_capacity.c instrument.c aip3368h_display.c io_key.c ui.c boot_animation.c
